Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 4ee71998-7a6e-489f-a289-5877b0e1d862, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 37502100(2025).ifc
Time: 2025-11-19T21:57:21+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: 37502100(2025):37502100 Spout, L=180, 37502100(2025):37502100 Spout, L=180:15579
In: Level 1
Type - Material: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 37502100(2025); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 37502100; Name: 37502100 Spout, L=180; ReplacementCost: n/a; Shape: Sculptured; Size: 75x75x205 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - NominalDepth: 203.141 mm; NominalHeight: 75 mm; NominalWidth: 75 mm
Type - General - Author: BIMStone; BIMObjectName: 37502100(2025); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_97; Uniclass2015Description: Washbasin spouts; Uniclass2015Reference: Pr_40_20_87_97; Version: 1; VersionDate: 2025/11/20
Type - Green Building Properties - EN Standard: EN 817; ETIM Class Number: EC011421 Outlet for sanitary taps; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/37502100; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 3D View: https://static.hansa.com/3D/37502100; Catalog Drawing URL: http://static.hansa.com/catdrw/37502100; Category B2B: Accessories; Category B2C: Bathroom; Color variants: 3750210033;3750210080;3750210081; Dimension Drawing URL: http://static.hansa.com/dimdrw/37502100; FDV Document URL: http://www.hansa.com/datasheet/37502100/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/37502100; Group: Spout; Interactive AR View URL: https://static.hansa.com/AR/37502100; Manufacturer: HANSA; Market: International;Poland;Germany;Austria;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/37502100; Model: 37502100 Spout, L=180; Name_en: 37502100 Spout, L=180; OmniClass Number: 23.31.11.00; OmniClass Title: Faucets; Product Code: 37502100; Product Family: HANSAGENESIS; Product Image URL: http://static.hansa.com/image/37502100; Product URL: http://static.hansa.com/37502100; Spare-Part Information URL: http://static.hansa.com/sp/37502100; Technical DataSheet URL: http://www.hansa.com/datasheet/37502100/en; Type Name: 37502100 Spout, L=180; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Aerator: Hidden aerator;PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Concealed Parts: Round rosette; Connection Size: G1/2; CWFU: 0; Flow Rate At 300kPa: 0.85 dm3/s; Max. Hot Water Supply: 90 C; Spout Projection: 185 mm; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 37502100; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 37502100 Spout, L=180
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 37502100 Spout, L=180; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 37502100(2025); Family and Type: 37502100(2025): 37502100 Spout, L=180; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 37502100 Spout, L=180; Type Id: 15557; WarrantyStartDate: n/a
Constraints - DefaultElevation: 900.023 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0360962 m2; Volume: 0.00114267 m3
Identity Data - Mark: 6
Phasing - Phase Created: New Construction
